# Keil uVision project FLY_Z.uvprojx, settings and files
target FLY_Z (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: FLY_Z +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./common;./FreeRTOS;./FreeRTOS/include;./FreeRTOS/protable;./Application;./interface;./interface/fix_height
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c i2c.c spi.c tim.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group common
    ./common/: Com_debug.c Com_debug.h Com_config.h Com_filter.c Com_filter.h Com_imu.c Com_imu.h Com_pid.c Com_pid.h
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c FreeRTOSConfig.h list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Include
    ./FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/protable
    ./FreeRTOS/protable/: heap_4.c port.c portmacro.h
  group Application
    ./Application/: APP_FreeRTOS_Task.c APP_FreeRTOS_Task.h APP_receive_data.c APP_receive_data.h APP_transmit_data.c APP_transmit_data.h APP_flight.c APP_flight.h APP_led_control.c APP_led_control.h
  group interface
    ./interface/: Int_TP4366.c Int_TP4366.h Int_motor.c Int_motor.h Int_LED.c Int_LED.h Int_SI24R1.c Int_SI24R1.h Int_MPU6050.c Int_MPU6050.h Int_bat_ADC.c Int_bat_ADC.h Int_VL53L1X.c Int_VL53L1X.h Int_VL53L0X.c Int_VL53L0X.h
  group interface/fix_height
    ./interface/fix_height/: vl53l1_platform.c vl53l1_platform.h vl53l1_types.h VL53L1X_api.c VL53L1X_api.h VL53L1X_calibration.c VL53L1X_calibration.h vl53l0x_api.c vl53l0x_api.h VL53L0X.c VL53L0X.h
software components: CMSIS:CORE 4.3.0
